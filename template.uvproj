# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: template
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_240000
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Header
    ./inc/: gpio.h main.h delay.h macro.h timer.h
  group Source
    ./source/: gpio.c delay.c timer.c
